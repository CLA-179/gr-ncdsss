options:
  parameters:
    author: clouda
    generate_options: qt_gui
    id: dsssen
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: char_rate
  id: variable
  parameters:
    value: '16384'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '3069000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_T
    period: '1000'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: symbol_rate * 2
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1, -1]'
  states: {}
- name: lilacsat_bpsk_demod_cb_0
  id: lilacsat_bpsk_demod_cb
  parameters: {}
  states: {}
- name: ncdsss_DSSS_Decoder_0
  id: ncdsss_DSSS_Decoder
  parameters:
    n1: '814'
    n2: '836'
    x1: '127'
    x2: '73'
  states: {}
- name: ncdsss_DSSS_Encoder_0
  id: ncdsss_DSSS_Encoder
  parameters:
    data_rate: '16384'
    n1: '0x32e'
    n2: '0x344'
    x1: '0x7f'
    x2: '0x49'
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xFF'
    maxsize: '1024'
    minsize: '1024'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_repeat_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', lilacsat_bpsk_demod_cb_0, '0']
- [lilacsat_bpsk_demod_cb_0, '0', ncdsss_DSSS_Decoder_0, '0']
- [ncdsss_DSSS_Decoder_0, '0', blocks_char_to_float_0, '0']
- [ncdsss_DSSS_Encoder_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [pdu_random_pdu_0, pdus, blocks_message_debug_0, print]
- [pdu_random_pdu_0, pdus, ncdsss_DSSS_Encoder_0, in]

metadata:
  file_format: 1
