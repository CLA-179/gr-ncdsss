options:
  parameters:
    author: clouda
    generate_options: qt_gui
    id: dsss_sat
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alg
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_0
    step_size: equalizer_gain
    type: lms
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: damp_factor
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: equalizer_gain
  id: variable_qtgui_range
  parameters:
    label: 'Equalizer: Gain'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '0.05'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 70e6
    step: 1e3
    stop: 2.5e9
    value: 70e6
  states: {}
- name: fc_t
  id: variable_qtgui_range
  parameters:
    start: 70e6
    step: 1e3
    stop: 2.5e9
    value: 70e6
  states: {}
- name: fll_bw
  id: variable_qtgui_range
  parameters:
    label: 'FLL: Bandwidth'
    start: '0.0'
    step: '0.001'
    stop: '0.2'
    value: '0.01'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: gain_t
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '10e-3'
  states: {}
- name: loop_bw_1
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '6138000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    label: 'Time: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '0.05'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/clouda/tgrc/l3r1.wav
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '6138000'
    type: complex
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw_1
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damp_factor
    loop_bw: loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: lilacsat_sync_det_b_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: ncdsss_DSSS_Decoder_0
  id: ncdsss_DSSS_Decoder
  parameters:
    n1: '0x286'
    n2: '0x273'
    x1: '0x188'
    x2: '0xc9'
  states: {}
- name: ncdsss_DSSS_Encoder_0_0
  id: ncdsss_DSSS_Encoder
  parameters:
    data_rate: '16384'
    n1: '0x286'
    n2: '0x273'
    x1: '0x188'
    x2: '0xC9'
  states: {}
- name: ncdsss_char_Resampler_0
  id: ncdsss_char_Resampler
  parameters:
    data: '16384'
    symbol: '3069000'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 192.168.1.118
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 192.168.1.118
    mtu: '10000'
    port: '52002'
    type: TCP_SERVER
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: A
    legend: 'False'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_3
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc_t
    gain0: gain_t
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: gain
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_1_3, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_repeat_0, '0', blocks_null_sink_0, '0']
- [blocks_repeat_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_map_bb_0, '0', ncdsss_DSSS_Decoder_0, '0']
- [digital_map_bb_0_0, '0', lilacsat_sync_det_b_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [lilacsat_sync_det_b_0, out, blocks_message_debug_0, print_pdu]
- [lilacsat_sync_det_b_0, out, network_socket_pdu_0, pdus]
- [lilacsat_sync_det_b_0_0, out, blocks_message_debug_0, print_pdu]
- [lilacsat_sync_det_b_0_0, out, network_socket_pdu_0, pdus]
- [ncdsss_DSSS_Decoder_0, '0', blocks_char_to_float_0_0_0, '0']
- [ncdsss_DSSS_Decoder_0, '0', ncdsss_char_Resampler_0, '0']
- [ncdsss_DSSS_Encoder_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [ncdsss_char_Resampler_0, '0', digital_map_bb_0_0, '0']
- [ncdsss_char_Resampler_0, '0', lilacsat_sync_det_b_0, '0']
- [network_socket_pdu_0_0, pdus, blocks_message_debug_0_0, print]
- [network_socket_pdu_0_0, pdus, ncdsss_DSSS_Encoder_0_0, in]
- [uhd_usrp_source_0, '0', digital_symbol_sync_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
